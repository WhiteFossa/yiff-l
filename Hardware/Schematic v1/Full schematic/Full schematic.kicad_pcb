# Repository WhiteFossa/yiff-l (continued)

## KiCad design Hardware/Full schematic/Full schematic/Full schematic.kicad_pcb

Parts:
C1: 100uFx16V; CP_Radial_D6.3mm_P2.50mm
C2, C3, C4, C5, C7, C8, C18, C24, C54, C56, C59, C61, C62, C64, C65, C66, C68, C69, C70, C74, C86, C94, C98, C99, C100, C108, C109, C112: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6, C30, C37, C38, C39, C41, C42, C43, C51, C55, C71, C77, C96, C97: 1nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9, C10, C11, C12: 22uFx16V; CP_Radial_D4.0mm_P2.00mm
C13: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C14, C15, C16, C17, C23, C34, C35, C45, C46, C47, C52, C57, C60, C67, C85: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C19: 150pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C20: 220pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C21, C22, C26, C27, C28, C32, C63, C73, C76, C78, C81, C93, C95: 10nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C25: 180pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C29: 1000uF x 10V; CP_Radial_D10.0mm_P5.00mm
C31, C44, C120, C121, C122, C123, C124, C125: 47pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C33, C114, C115, C116, C117, C118, C119: 100pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C36, C113: 56pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C40: 10uFx25V tantalum; CP_EIA-7132-28_AVX-C_Pad2.72x3.50mm_HandSolder
C48, C49, C50: 220uFx6.3V; CP_Radial_D6.3mm_P2.50mm
C53, C58: 1000uF x 25V; CP_Radial_D10.0mm_P5.00mm
C72, C84: 75pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C75: 100uFx6.3V; CP_Radial_D6.3mm_P2.50mm
C79, C80: 22pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C82, C83: 8pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C87, C88, C89, C90, C91, C92: 390pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C101: 20pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C102, C103, C104, C105, C106, C107: 200pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C110: 100uF x 16V; CP_Radial_D6.3mm_P2.50mm
C111: 22uF x 10V; CP_Radial_D4.0mm_P2.00mm
C126, C127, C128, C129, C130, C131: 24pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C132, C133, C134, C135, C136, C137: 12pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2, D3, D8, D9, D10, D11, D13: 1N4148W; D_SOD-123
D4, D5, D6, D7: MBR0520; D_SOD-123
D12: 1N5819; D_DO-27_P5.08mm_Vertical_AnodeUp
D14: 1N4728A; D_DO-41_SOD81_P10.16mm_Horizontal
DA1: AD825; SOIC-8_3.9x4.9mm_P1.27mm
J1, J6, J9: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
J2: Reset; PinHeader_1x02_P2.54mm_Vertical
J3: Encoder; PinHeader_1x04_P2.54mm_Vertical
J4: Failure LED; PinHeader_1x02_P2.54mm_Vertical
J5: Bluetooth; PinHeader_1x04_P2.54mm_Vertical
J7: Display; PinHeader_1x04_P2.54mm_Vertical
J8: Buttons; PinHeader_1x03_P2.54mm_Vertical
J10: Conn_01x01_Male; PinHeader_1x01_P2.54mm_Vertical
JP1: BOOT0; PinHeader_1x03_P2.54mm_Vertical
JP2: BOOT1; PinHeader_1x03_P2.54mm_Vertical
JP3: SWDIO; PinHeader_1x02_P2.54mm_Vertical
JP4: SWCLK; PinHeader_1x02_P2.54mm_Vertical
K1, K2, K3, K4, K5, K6: EDR101A0500; Relay_SPST_StandexMeder_SIL_Form1A
L1, L3, L4, L5, L11: 10uH; L_1812_4532Metric_Pad1.30x3.40mm_HandSolder
L2, L9: 3.3uH; L_1812_4532Metric_Pad1.30x3.40mm_HandSolder
L6, L7: 4.7uH; L_1812_4532Metric_Pad1.30x3.40mm_HandSolder
L8: 50uH; L_Toroid_Vertical_L25.4mm_W14.7mm_P12.20mm_Vishay_TJ5_BigPa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
L10: 150uH; L_12x12mm_H8mm
L12: 21uH; L_Toroid_Vertical_L21.6mm_W9.1mm_P8.40mm_Bourns_5700
L13: 200nH; L_Axial_L5.3mm_D2.2mm_P7.62mm_Horizontal_Vishay_IM-1
L14: 300nH; L_Axial_L16.0mm_D7.5mm_P7.62mm_Vertical_Fastron_XHBCC
L15: 23.5nH; L_Axial_L9.5mm_D4.0mm_P5.08mm_Vertical_Fastron_SMCC
Q1, Q2, Q3, Q4, Q5, Q11, Q13, Q15, Q17, Q19: BC847; SOT-23
Q6, Q8, Q9, Q10, Q18, Q21: IRLML6402; SOT-23
Q7: IRF4905; TO-220-3_Vertical
Q12: IRFZ44; TO-220-3_Vertical
Q14: BSS138; SOT-23
Q16: IRF610; TO-220-3_Vertical
Q20: BFS17; SOT-23
Q22: AFT05MS003N; SOT-89-3_Handsoldering
Q23, Q24, Q25, Q26, Q27, Q28: IRLML2502; SOT-23
R1, R2, R3, R25, R26, R27, R52, R54, R61, R89, R93, R94, R95, R96, R97: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R5, R11, R17: 47k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6, R7, R8, R9, R10, R12, R13, R14, R15, R16, R23, R37, R39, R41, R43, R68, R69, R77, R79, R81: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R18, R19, R20, R21, R22, R42, R74, R85: 10; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R24, R48, R56, R64, R65, R67, R70, R73, R78, R80, R84, R86, R87, R88, R90, R91, R92: 4.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R28: 1.3k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R29: 150k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R30: 12k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R31: 300; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R32, R35: 13k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R33, R62: 3.9k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R34: 120k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R36: 51k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R38, R75: 39k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R40, R50, R58: 30k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R44, R53, R60, R83: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R45, R46, R47, R49: 1; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R51, R59: 6.8k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R55: 36k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R57: 56k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R63: 2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R66: 33k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R71: 220k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R72: 11k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R76: 33; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R82: 6.2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RV1, RV2: 20k; Potentiometer_Bourns_3386C_Horizontal
U1, U2: 74LVC2T45DC; VSSOP-8_2.3x2mm_P0.5mm
U3: AD9835; SSOP-16_4.4x5.2mm_P0.65mm
U4: LM27313XMF; SOT-23-5
U5, U6, U7: LM2734X; TSOT-23-6
U8: UC3843_SOIC8; SOIC-8_3.9x4.9mm_P1.27mm
U9: AD5245BRJZ10; SOT-23-8_Handsoldering
U10: ICS501; SOIC-8_5.23x5.23mm_P1.27mm
U11: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U12: CAT24C256; SOIC-8_5.23x5.23mm_P1.27mm
X1: 50MHz; Oscillator_DIP-8
Y1: 8MHz; Crystal_HC49-U_Vertical
Y2: 32768Hz; Crystal_C26-LF_D2.1mm_L6.5mm_Horizontal_1EP_style1

Connections:
ACTIVATE_3.5: D2.2 (A), R4.1, R7.2, R8.2, U11.19 (PB1)
ACTIVATE_144: D3.2 (A), R9.2, R10.2, R11.1, U11.40 (PB4)
ACTIVATE_DISPLAY: R17.1, U6.4 (EN), U11.41 (PB5)
ACTIVATE_FOX: D1.2 (A), U11.39 (PB3)
ADC_U3.5_OUT: R66.2, R67.1, U11.12 (PA2)
ADC_UANT: D14.1 (K), R75.1, R77.1, U11.10 (PA0)
ADC_UBATT: C6.1, R23.2, R24.1, U11.11 (PA1)
ANT_3.5: C87.1, C102.1, C114.1, C120.1, C126.1, C132.1, J6.2, L12.2, R71.1
BATT_7.4V: C1.1, C9.1, C10.1, C11.1, C14.1, C15.1, C16.1, J1.1, Q6.2 (S), Q7.3 (S), Q9.2 (S), R12.1, R13.1, R15.1, U5.5 (VIN), U6.5 (VIN), U7.4 (EN), U7.5 (VIN)
BOOT0: JP1.2 (C), U11.44 (BOOT0)
BOOT1: JP2.2 (C), U11.20 (PB2)
BTN_LEFT: C95.1, J8.1, R91.2, U11.14 (PA4)
BTN_RIGHT: C93.1, J8.2, R88.2, U11.16 (PA6)
BT_5V: J5.1, Q18.3 (D)
BT_RX: J5.3, U11.31 (PA10)
BT_TX: J5.4, U11.30 (PA9)
COMM_5V_ENABLE: D1.1 (K), D2.1 (K), D3.1 (K), R5.1, U5.4 (EN)
DDS_FSYNC: R3.2, U11.29 (PA8)
DDS_SCLK: R1.2, U11.15 (PA5)
DDS_SDATA: R2.2, U11.17 (PA7)
DISPLAY_4V: C38.1, C42.1, C46.1, C49.1, D9.2 (A), J7.2, L4.2, R38.1
DISPLAY_SCL: J7.3, R86.2, U11.42 (PB6)
DISPLAY_SDA: J7.4, R87.2, U11.43 (PB7)
ENABLE_BT: R68.2, U11.46 (PB9)
ENABLE_UBATT_CHECK: R6.2, U11.45 (PB8)
ENCODER_BTN: C76.1, J3.3, R78.2, U11.27 (PB14)
ENCODER_L: C81.1, J3.1, R84.2, U11.25 (PB12)
ENCODER_R: C78.1, J3.2, R80.2, U11.26 (PB13)
FAIL_LED: J4.1, U11.2 (PC13)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C20.2, C22.2, C23.2, C29.2, C30.2, C31.2, C33.2, C34.2, C35.2, C36.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C55.2, C57.2, C58.2, C59.2, C60.2, C62.2, C63.2, C64.2, C66.2, C67.2, C68.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, C78.2, C79.2, C80.2, C81.2, C82.2, C83.2, C85.2, C86.2, C93.2, C94.2, C95.2, C96.2, C98.2, C99.2, C100.2, C101.2, C108.1, C109.2, C110.2, C111.2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
I2C2_SCL: R90.2, U9.4 (SCL), U11.21 (PB10), U12.6 (SCL)
I2C2_SDA: R92.2, U9.5 (SDA), U11.22 (PB11), U12.5 (SDA)
MANIP_144: L13.1, Q21.3 (D), RV2.1
MATCH_0: R97.2, U11.13 (PA3)
MATCH_1: R96.2, U11.32 (PA11)
MATCH_2: R95.2, U11.33 (PA12)
MATCH_3: JP3.2, R94.2
MATCH_4: JP4.2, R93.2
MATCH_5: R89.2, U11.38 (PA15)
Manipulation: R52.2, R79.2, U11.18 (PB0)
unnamed: C13.1, Q11.3 (C), R30.1, U8.8 (VREF)
unnamed: C19.1, R29.1, U8.1 (COMP)
unnamed: C19.2, R29.2, R55.2, R56.1, U8.2 (FB)
unnamed: C20.1, Q11.1 (B), R30.2, U8.4 (RC)
unnamed: C21.2, U3.16 (COMP)
unnamed: C22.1, U3.2 (REFIN), U3.3 (REFOUT)
unnamed: C24.1, L2.1
unnamed: C24.2, R31.1, U3.14 (IOUT)
unnamed: C25.2, R32.1, R34.2, U4.3 (FB)
unnamed: C26.1, D5.1 (K), L3.1, U5.6 (SW)
unnamed: C26.2, D8.1 (K), U5.1 (BOOST)
unnamed: C27.1, D6.1 (K), L4.1, U6.6 (SW)
unnamed: C27.2, D9.1 (K), U6.1 (BOOST)
unnamed: C28.1, D7.1 (K), L5.1, U7.6 (SW)
unnamed: C28.2, D10.1 (K), U7.1 (BOOST)
unnamed: C31.1, L2.2, L6.1
unnamed: C32.1, C33.1, R44.2, U8.3 (CS)
unnamed: C32.2, R35.1
unnamed: C36.1, L6.2, L7.1
unnamed: C37.2, R36.2, R37.1, U5.3 (FB)
unnamed: C38.2, R38.2, R39.1, U6.3 (FB)
unnamed: C39.2, R40.2, R41.1, U7.3 (FB)
unnamed: C44.1, L7.2, L9.1
unnamed: C51.1, C52.1, C53.1, D12.1 (K), L10.1
unnamed: C54.1, C56.2, L9.2, R48.1
unnamed: C54.2, Q13.1 (B), R50.2, R51.1
unnamed: C56.1, DA1.3 (+IN), RV1.2
unnamed: C61.1, Q15.1 (B), R58.2, R59.1
unnamed: C61.2, Q13.3 (C), R53.2
unnamed: C62.1, Q13.2 (E), R54.1
unnamed: C63.1, Q14.3 (D), R57.2, RV1.3
unnamed: C65.1, R64.2, R65.1, U10.1 (XI/ICLK)
unnamed: C65.2, Q15.3 (C), R60.2
unnamed: C66.1, Q15.2 (E), R61.1
unnamed: C69.1, C72.1, L12.1
unnamed: C69.2, L11.2, Q16.2 (D)
unnamed: C73.1, D13.1 (K), R75.2
unnamed: C77.1, Q20.1 (B), R82.2, R83.1
unnamed: C77.2, R76.1, U10.5 (CLK)
unnamed: C79.1, U11.5 (PD0), Y1.2
unnamed: C80.1, U11.6 (PD1), Y1.1
unnamed: C82.1, U11.3 (PC14), Y2.2
unnamed: C83.1, U11.4 (PC15), Y2.1
unnamed: C84.1, Q22.1 (G), RV2.2
unnamed: C84.2, L13.2, Q20.3 (C)
unnamed: C87.2, C88.1
unnamed: C88.2, C89.1
unnamed: C89.2, C90.1
unnamed: C90.2, C91.1
unnamed: C91.2, C92.1
unnamed: C92.2, K1.1
unnamed: C97.2, L14.2, Q22.3 (D)
unnamed: C97.1, C101.1, L15.1
unnamed: C102.2, C103.1
unnamed: C103.2, C104.1
unnamed: C104.2, C105.1
unnamed: C105.2, C106.1
unnamed: C106.2, C107.1
unnamed: C107.2, K2.1
unnamed: C113.1, J9.2, L15.2
unnamed: C114.2, C115.1
unnamed: C115.2, C116.1
unnamed: C116.2, C117.1
unnamed: C117.2, C118.1
unnamed: C118.2, C119.1
unnamed: C119.2, K3.1
unnamed: C120.2, C121.1
unnamed: C121.2, C122.1
unnamed: C122.2, C123.1
unnamed: C123.2, C124.1
unnamed: C124.2, C125.1
unnamed: C125.2, K4.1
unnamed: C126.2, C127.1
unnamed: C127.2, C128.1
unnamed: C128.2, C129.1
unnamed: C129.2, C130.1
unnamed: C130.2, C131.1
unnamed: C131.2, K5.1
unnamed: C132.2, C133.1
unnamed: C133.2, C134.1
unnamed: C134.2, C135.1
unnamed: C135.2, C136.1
unnamed: C136.2, C137.1
unnamed: C137.2, K6.1
unnamed: D4.2 (A), L1.2, U4.1 (SW)
unnamed: D11.1 (K), R42.2, U8.6 (OUT)
unnamed: D11.2 (A), Q12.1 (G), R42.1, R43.1
unnamed: D12.2 (A), L8.2, Q12.2 (D)
unnamed: D13.2 (A), R71.2, R72.1
unnamed: DA1.2 (-IN), R62.2, R63.1
unnamed: DA1.6 (OUT), Q16.1 (G), R62.1
unnamed: K1.5, Q23.3 (D)
unnamed: K2.5, Q24.3 (D)
unnamed: K3.5, Q25.3 (D)
unnamed: K4.5, Q26.3 (D)
unnamed: K5.5, Q27.3 (D)
unnamed: K6.5, Q28.3 (D)
unnamed: Q1.1 (B), R6.1
unnamed: Q1.3 (C), R18.2
unnamed: Q2.1 (B), R7.1
unnamed: Q2.3 (C), R19.2
unnamed: Q3.1 (B), R8.1
unnamed: Q3.3 (C), R20.2
unnamed: Q4.1 (B), R9.1
unnamed: Q4.3 (C), R21.2
unnamed: Q5.1 (B), R10.1
unnamed: Q5.3 (C), R22.2
unnamed: Q6.1 (G), R12.2, R18.1
unnamed: Q6.3 (D), R23.1
unnamed: Q7.1 (G), R13.2, R19.1
unnamed: Q8.1 (G), R14.2, R20.1
unnamed: Q9.1 (G), R15.2, R21.1
unnamed: Q10.1 (G), R16.2, R22.1
unnamed: Q11.2 (E), R28.1, R35.2
unnamed: Q12.3 (S), R44.1, R45.1, R46.1, R47.1, R49.1
unnamed: Q14.1 (G), R52.1
unnamed: Q17.1 (B), R68.1
unnamed: Q17.3 (C), R74.2
unnamed: Q18.1 (G), R69.2, R74.1
unnamed: Q19.1 (B), R79.1
unnamed: Q19.3 (C), R85.2
unnamed: Q21.1 (G), R81.2, R85.1
unnamed: Q23.1 (G), R89.1
unnamed: Q24.1 (G), R93.1
unnamed: Q25.1 (G), R94.1
unnamed: Q26.1 (G), R95.1
unnamed: Q27.1 (G), R96.1
unnamed: Q28.1 (G), R97.1
unnamed: R1.1, U1.2 (1A)
unnamed: R2.1, U1.3 (2A)
unnamed: R3.1, U2.2 (1A)
unnamed: R25.1, U3.8 (SDATA)
unnamed: R25.2, U1.6 (2B)
unnamed: R26.1, U3.9 (FSYNC)
unnamed: R26.2, U2.7 (1B)
unnamed: R27.1, U3.7 (SCLK)
unnamed: R27.2, U1.7 (1B)
unnamed: R33.2, U3.1 (FS_ADJUST)
unnamed: R56.2, U9.1 (W), U9.8 (A)
unnamed: R70.2, U10.7 (OE)
unnamed: U3.6 (MCLK), X1.5 (OUT)
POWERS_3.5: C12.1, C17.1, C29.1, C34.1, L1.1, L8.1, Q7.2 (D), U4.4 (EN), U4.5 (VIN)
PWR_3.5_5: C111.1, C112.1, K1.3, K2.3, K3.3, K4.3, K5.3, K6.3, Q8.3 (D)
PWR_3.5_12: C23.1, C25.1, C30.1, C35.1, C40.1, C59.1, C60.1, D4.1 (K), DA1.7 (+VS), R34.1, R57.1, U8.7 (VCC)
PWR_3.5_OUT: C55.1, C57.1, C58.1, C67.1, C68.1, L10.2, L11.1, R55.1, R66.1
PWR_144_5: C71.1, C74.1, C75.1, Q10.3 (D), Q21.2 (S), R50.1, R53.1, R58.1, R60.1, R64.1, R70.1, R81.1, R82.1, U10.2 (VDD), U10.4 (S1), U10.6 (S0)
PWR_144_OUT: C96.1, C99.1, C110.1, L14.1, Q9.3 (D)
REG_3.3V: C2.1, C3.1, C39.1, C43.1, C47.1, C50.1, C64.1, C85.1, C86.1, C94.1, C98.1, C100.1, C108.2, C109.1, D10.2 (A), JP1.3 (B), JP2.3 (B), L5.2, R40.1, R73.1, R78.1, R80.1, R84.1, R86.1, R87.1, R88.1, R90.1, R91.1, R92.1, U1.1 (VCCA), U1.5 (DIR), U2.1 (VCCA), U2.5 (DIR), U9.2 (Vdd), U11.1 (VBAT), U11.9 (VDDA), U11.24 (VDD), U11.36 (VDD), U11.48 (VDD), U12.8 (VCC)
REG_5V: C4.1, C5.1, C7.1, C8.1, C18.1, C21.1, C37.1, C41.1, C45.1, C48.1, D8.2 (A), L3.2, Q8.2 (S), Q10.2 (S), Q18.2 (S), R14.1, R16.1, R36.1, R69.1, U1.8 (VCCB), U2.8 (VCCB), U3.4 (DVDD), U3.15 (AVDD), X1.8 (Vcc)
RESET: C70.1, J2.1, R73.2, U11.7 (NRST)
SWCLK: JP4.1, U11.37 (PA14)
SWDIO: JP3.1, U11.34 (PA13)

Notes on the sheet:
Peak to peak (in): 3.50MHz - 0.34V 3.65MHz - 0.3V 18.00MHz - 1.5V 18.25MHz - 1V
Peak to peak (out): 3.50MHz - 0.96V 3.65MHz - 0.96V 18.00MHz - 77mV 18.25MHz - 77mV
To 3.5MHz antenna
200V P-P at antenna equivalent. Antenna equivalent is 240 Ohm resistor in series with 35pF capacitor.
0.00972*Uant
4pF
8pF
16pF
32pF
64pF
2pF
144-146MHz 1.5V P-P 8.5mW @ 33 Ohm
3V P-P 18MHz
M50BH 20x12x6 ring
6T D5 d0.5
4.32V P-P @ 10 Ohm
To 144MHz 50 Ohm antenna
8T D7 d0.5
3T D3 d0.5
Address = A0H
GND
VCC
HC-06 Bluetooth
7.4V 2 cells
+7.4V
1 - Enable 0 - Disable
Power sources activation logic
1 - Enable 3.5MHz powers 0 - Disable 3.5MHz powers
ADC_UBATT=0.32UBATT
ADC_U3.5_OUT=0.125PWR_3.5_OUT
Boot mode selection
SCL
SDA
SSD1327 Display
Left
Right
Button
Failure LED
Programming
1 - Off 0 - On

Board: 2 copper layers, 159.3 x 59.9 mm, 329 parts (74 on the bottom side), 192 nets.

## KiCad design Hardware/VCO/Schematics/VCO-testboard.kicad_pcb

Board: 2 copper layers, 29 parts (0 on the bottom side), 13 nets.

Parts:
C1, C2, C6, C7, C8: 0.1uF; C_0805_HandSoldering
C3: 47pF; C_0805_HandSoldering
C4, C5: 560pF; C_0805_HandSoldering
D1, D2: 1N4148; D_0805
DA1: AD8031; SOIC-8-N
J1, J2, J3, J4: Conn_01x02; Pin_Header_Straight_1x02
L1: 27 uH; Neosid_Inductor_Sd8
R1, R4, R9: 100k; R_0805_HandSoldering
R2, R3, R6: 47k; R_0805_HandSoldering
R5: 470; R_0805_HandSoldering
R7: 4.7k; R_0805_HandSoldering
R8: 10k; R_0805_HandSoldering
U1: LM358; SOIC-8-N
VD1, VD2: BB135; D_0805
VT1: BF862; SOT-23

Connections:
+12V: C8.1, DA1.7, J2.1, R2.1, U1.8, VT1.2
GND: C2.2, C5.2, C6.2, C8.2, D1.2, D2.1, DA1.4, J1.2, J2.2, J3.2, J4.2, L1.2, R3.2, R4.2, R5.2, U1.4, VD1.2, VD2.2
unnamed: C1.1, C3.2, D1.1, D2.2, L1.1
unnamed: C1.2, R1.1, VD1.1, VD2.1
unnamed: C2.1, R2.2, R3.1, U1.3
unnamed: C3.1, C4.1, R4.1, VT1.3
unnamed: C4.2, C5.1, C7.1, R5.1, VT1.1
unnamed: C6.1, J3.1, R6.2, R7.2, U1.1, U1.2
unnamed: C7.2, DA1.3, R6.1
unnamed: DA1.2, R7.1, R8.1
unnamed: DA1.6, J4.1, R9.2
unnamed: J1.1, R1.2
unnamed: R8.2, R9.1

File Hardware/VCO/Schematics/VCO_BOM.csv:

Reference, Value, Footprint, Datasheet
"C8","0.1uF","",""
"VT1","BF862","",""
"C4","560pF","",""
"C5","560pF","",""
"R4","100k","",""
"C3","47pF","",""
"C1","0.1uF","",""
"VD2","BB135","",""
"R1","100k","",""
"VD1","BB135","",""
"J1","Conn_01x02","",""
"J2","Conn_01x02","",""
"J4","Conn_01x02","",""
"D1","1N4148","",""
"D2","1N4148","",""
"R5","470","",""
"C7","0.1uF","",""
"L1","27 uH","",""
"R8","110k","",""
"DA1","AD8031","",""
"R7","4.7k","",""
"R6","47k","",""
"C2","0.1uF","",""
"R3","47k","",""
"R2","47k","",""
"U1","LM358","",""
"C6","0.1uF","",""
"J3","Conn_01x02","",""

## Code that names these connections

File Firmware/yiff-experimental/include/hal.h:

/*
 * Hardware abstractions layer
 */

#ifndef INCLUDE_HAL_H_
#define INCLUDE_HAL_H_

#include <stddef.h>
#include <stdint.h>
#include <l2hal.h>
#include <l2hal_ad9835.h>

/**
 * !!! HARDWARE CONNECTIONS !!!
 *
 * PA0 - Encoder 1
 * PA1 - Encoder 2
 * PA2 - Encoder button
 *
 * PA3 - Detector output (ADC12_IN3)
 *
 * PA5 - AD9835 SCLK
 * PA7 - AD9835 SDATA
 * PA8 - AD9835 FSYNC
 *
 *
 */

/**
 * Averaging over 256 detector measurements.
 */
#define HAL_DETECTOR_AVERAGING 10000

/**
 * Here we accumulating values from detector.
 */
uint32_t HalDetectorAccumulator;

/**
 * Counter for averaging
 */
uint16_t HalDetectorAveragingCounter;

/**
 * Averaged value of detector
 */
uint16_t HalDetectorAverage;

/**
 * True when detector value updated, user have to reset in manually.
 */
bool HalIsDetectorValueUpdated;

/**
 * Initialize hardware
 */
void HalInitHardware(void);

/**
 * Initialize PLL and set after initialization frequency.
 */
void HalInitPll(uint32_t frequency);

/**
 * Set PLL frequency.
 */
void HalSetPllFrequency(uint32_t frequency);

/**
 * Set up detector ADC
 */
void HalSetupADC(void);

/**
 * Initialize antenna matching unit
 */
void HalInitAntennaMatching(void);

/**
 * Set antenna matching level
 */
void HalSetAntennaMatching(uint8_t matching);

/**
 * Initialize manipulation output
 */
void HalInitManipulator(void);

/**
 * Switch manipulator.
 */
void HalSwitchManipulator(bool isOn);

/**
 * Called when detector value is updated.
 */
void HalOnDetectorValueUpdated(uint16_t detectorValue);

#endif /* INCLUDE_HAL_H_ */
