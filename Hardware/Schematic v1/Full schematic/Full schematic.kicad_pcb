# Repository WhiteFossa/yiff-l

File README.md:

3rd party code used:
https://github.com/mpaland/printf - MIT

## KiCad design Hardware/Schematic v1/Full schematic/Full schematic.kicad_pcb

Parts:
C1: 100uFx16V; CP_Radial_D6.3mm_P2.50mm
C2, C3, C4, C5, C7, C8, C18, C23, C52, C54, C56, C59, C60, C62, C63, C64, C66, C67, C69, C72, C84, C85, C87, C91, C92, C94, C95, C97, C98: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6, C30, C33, C37, C38, C42, C43, C49, C53, C68, C75, C89, C90: 1nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9, C10, C11, C12: 22uFx16V; CP_Radial_D4.0mm_P2.00mm
C13: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C14, C15, C16, C17, C24, C34, C35, C39, C45, C46, C50, C55, C58, C65, C83, C101, C102, C103, C104, C107, C108, C109, C110, C113, C114, C115, C116: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C19: 150pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C20: 220pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C21, C22, C26, C27, C31, C61, C71, C74, C76, C79, C86, C88: 10nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C25: 180pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C28: 1000uF x 10V; CP_Radial_D10.0mm_P5.00mm
C29, C41: 47pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C32: 100pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C36, C99: 56pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C40: 10uFx25V tantalum; CP_EIA-7132-28_AVX-C_Pad2.72x3.50mm_HandSolder
C44, C47, C48: 220uFx6.3V; CP_Radial_D6.3mm_P2.50mm
C51, C57: 1000uF x 25V; CP_Radial_D10.0mm_P5.00mm
C70, C82: 75pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C73: 100uFx6.3V; CP_Radial_D6.3mm_P2.50mm
C77, C78: 22pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C80, C81: 8pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C93: 20pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C96: 100uF x 16V; CP_Radial_D6.3mm_P2.50mm
C100: 22uF x 10V; CP_Radial_D4.0mm_P2.00mm
C105, C119: 2pF 250V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C106: 16pF 250V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C111: 4pF 250V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C112: 32pF 250V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C117: 8pF 250V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C118: 62pF 250V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2, D3, D8, D9, D10, D12: 1N4148W; D_SOD-123
D4, D5, D6, D7: MBR0520; D_SOD-123
D11: 1N5819; D_DO-27_P5.08mm_Vertical_AnodeUp
D13: 1N4728A; D_DO-41_SOD81_P10.16mm_Horizontal
DA1: AD825; SOIC-8_3.9x4.9mm_P1.27mm
J1, J6, J9: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
J2: Reset; PinHeader_1x02_P2.54mm_Vertical
J3: Encoder; PinHeader_1x04_P2.54mm_Vertical
J4: Failure LED; PinHeader_1x02_P2.54mm_Vertical
J5: Bluetooth; PinHeader_1x04_P2.54mm_Vertical
J7: Display; PinHeader_1x04_P2.54mm_Vertical
J8: Buttons; PinHeader_1x03_P2.54mm_Vertical
J10: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
K1, K2, K3, K4, K5, K6: IM43TS; Mouser Part Number 655-IM43TS
L1, L3, L4, L11: 10uH; L_1812_4532Metric_Pad1.30x3.40mm_HandSolder
L2, L9: 3.3uH; L_1812_4532Metric_Pad1.30x3.40mm_HandSolder
L5: 22uH; L_1812_4532Metric_Pad1.30x3.40mm_HandSolder
L6, L7: 4.7uH; L_1812_4532Metric_Pad1.30x3.40mm_HandSolder
L8: 50uH; L_12x12mm_H8mm
L10: 150uH; L_12x12mm_H8mm
L12: 13uH; L_10.4x10.4_H4.8
L13: 200nH; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
L14: 300nH; 2222SQ301GEC
L15: 22nH; L_1206_3216Metric_Pad1.22x1.90mm_HandSolder
Q1, Q2, Q3, Q4, Q5, Q11, Q13, Q15, Q17, Q19, Q21: BC847; SOT-23
Q6, Q8, Q9, Q10, Q14, Q20, Q22: IRLML6402; SOT-23
Q7: IRF4905; TO-220-3_Vertical
Q12: IRFZ44; TO-220-3_Vertical
Q16: BSS138; SOT-23
Q18: IRF610; TO-220-3_Vertical
Q23: BFS17; SOT-23
Q24: AFT05MS003N; SOT-89-3_Handsoldering
R1, R2, R3, R26, R27, R28, R54, R56, R63: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R5, R11, R17, R23: 47k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6, R7, R8, R9, R10, R12, R13, R14, R15, R16, R24, R38, R40, R42, R49, R50, R70, R72, R79, R81, R82: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R18, R19, R20, R21, R22, R41, R51, R76, R87: 10; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R25, R47, R58, R66, R67, R69, R71, R75, R80, R83, R86, R89, R90, R91, R92, R93, R94, R95: 4.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R29: 1.3k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R30: 300; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R31: 150k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R32: 12k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R33, R64: 3.9k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R34, R36: 13k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R35: 120k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R37: 51k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R39, R77: 39k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R43, R55, R62, R85: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R44, R45, R46, R48: 1; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R52, R60: 30k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R53, R61: 6.8k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R57, R88: 36k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R59: 56k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R65: 2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R68: 33k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R73: 220k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R74: 11k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R78: 33; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R84: 6.2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RV1, RV2: 20k; Potentiometer_Bourns_3386C_Horizontal
U1, U2: 74LVC2T45DC; VSSOP-8_2.3x2mm_P0.5mm
U3: AD9835; SSOP-16_4.4x5.2mm_P0.65mm
U4: LM27313XMF; SOT-23-5
U5, U6: LM2734X; TSOT-23-6
U7: MAX1837EUT33-T; TSOT-23-6
U8: UC3843_SOIC8; SOIC-8_3.9x4.9mm_P1.27mm
U9: AD5245BRJZ10; SOT-23-8_Handsoldering
U10: ICS501; SOIC-8_5.23x5.23mm_P1.27mm
U11: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U12: MCP23017_SS; SSOP-28_5.3x10.2mm_P0.65mm
U13: CAT24C256; SOIC-8_5.23x5.23mm_P1.27mm
X1: 50MHz; Oscillator_DIP-8
Y1: 8MHz; Crystal_HC49-U_Vertical
Y2: 32768Hz; Crystal_C26-LF_D2.1mm_L6.5mm_Vertical

Connections:
ACTIVATE_3.3V: R23.1, R49.2, U11.28 (PB15)
ACTIVATE_3.5: D2.2 (A), R4.1, R7.2, R8.2, U11.19 (PB1)
ACTIVATE_144: D3.2 (A), R9.2, R10.2, R11.1, U11.40 (PB4)
ACTIVATE_DISPLAY: R17.1, U6.4 (EN), U11.41 (PB5)
ACTIVATE_FOX: D1.2 (A), U11.39 (PB3)
ADC_U3.5_OUT: R68.2, R69.1, U11.12 (PA2)
ADC_UANT: D13.1 (K), R77.1, R79.1, U11.10 (PA0)
ADC_UBATT: C6.1, R24.2, R25.1, U11.11 (PA1)
ANT_3.5: C105.2, C106.2, C111.2, C112.2, C117.2, C118.2, C119.1, J6.2, L12.2, R73.1
BATT_7.4V: C1.1, C9.1, C10.1, C11.1, C14.1, C15.1, C16.1, J1.1, Q6.2 (S), Q7.3 (S), Q9.2 (S), R12.1, R13.1, R15.1, U5.5 (VIN), U6.5 (VIN), U7.3 (IN), U7.5 (#SHDN)
BTN_LEFT: C88.1, J8.1, R94.2, U11.16 (PA6)
BTN_RIGHT: C86.1, J8.2, R92.2, U11.14 (PA4)
BT_5V: J5.1, Q20.3 (D)
BT_RX: J5.3, U11.31 (PA10)
BT_TX: J5.4, U11.30 (PA9)
COMM_5V_ENABLE: D1.1 (K), D2.1 (K), D3.1 (K), R5.1, U5.4 (EN)
DDS_FSYNC: R3.2, U11.29 (PA8)
DDS_SCLK: R1.2, U11.15 (PA5)
DDS_SDATA: R2.2, U11.17 (PA7)
DISPLAY_4V: C38.1, C43.1, C46.1, C48.1, D9.2 (A), J7.2, L4.2, R39.1
DISPLAY_SCL: J7.3, R89.2, U11.42 (PB6)
DISPLAY_SDA: J7.4, R90.2, U11.43 (PB7)
ENABLE_BT: R70.2, U11.46 (PB9)
ENABLE_UBATT_CHECK: R6.2, U11.45 (PB8)
ENCODER_BTN: C74.1, J3.3, R80.2, U11.25 (PB12)
ENCODER_L: C79.1, J3.1, R86.2, U11.27 (PB14)
ENCODER_R: C76.1, J3.2, R83.2, U11.26 (PB13)
FAIL_LED: J4.1, U11.2 (PC13)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C20.2, C22.2, C24.2, C28.2, C29.2, C30.2, C32.2, C33.2, C34.2, C35.2, C36.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C53.2, C55.2, C56.2, C57.2, C58.2, C60.2, C61.2, C62.2, C64.2, C65.2, C66.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C76.2, C77.2, C78.2, C79.2, C80.2, C81.2, C83.2, C84.2, C85.2, C86.2, C87.2, C88.2, C89.2, C91.2, C92.2, C93.2, C94.2, C95.1, C96.2, C97.2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
I2C2_SCL: R93.2, U9.4 (SCL), U11.21 (PB10), U12.12 (SCK), U13.6 (SCL)
I2C2_SDA: R95.2, U9.5 (SDA), U11.22 (PB11), U12.13 (SDA), U13.5 (SDA)
MANIP_144: L13.1, Q22.3 (D), R88.1
MATCH0+: C101.2, C103.2, U12.21 (GPA0)
MATCH0-: K1.8 (COIL-), U12.1 (GPB0)
MATCH1+: C107.2, C109.2, U12.22 (GPA1)
MATCH1-: K3.8 (COIL-), U12.2 (GPB1)
MATCH2+: C113.2, C115.2, U12.23 (GPA2)
MATCH2-: K5.8 (COIL-), U12.3 (GPB2)
MATCH3+: C102.2, C104.2, U12.24 (GPA3)
MATCH3-: K2.8 (COIL-), U12.4 (GPB3)
MATCH4+: C108.2, C110.2, U12.25 (GPA4)
MATCH4-: K4.8 (COIL-), U12.5 (GPB4)
MATCH5+: C114.2, C116.2, U12.26 (GPA5)
MATCH5-: K6.8 (COIL-), U12.6 (GPB5)
Manipulation: R54.2, R81.2, U11.18 (PB0)
unnamed: C13.1, Q11.3 (C), R32.1, U8.8 (VREF)
unnamed: C19.1, R31.1, U8.1 (COMP)
unnamed: C19.2, R31.2, R57.2, R58.1, U8.2 (FB)
unnamed: C20.1, Q11.1 (B), R32.2, U8.4 (RC)
unnamed: C21.2, U3.16 (COMP)
unnamed: C22.1, U3.2 (REFIN), U3.3 (REFOUT)
unnamed: C23.1, L2.1
unnamed: C23.2, R30.1, U3.14 (IOUT)
unnamed: C25.2, R34.1, R35.2, U4.3 (FB)
unnamed: C26.1, D5.1 (K), L3.1, U5.6 (SW)
unnamed: C26.2, D8.1 (K), U5.1 (BOOST)
unnamed: C27.1, D6.1 (K), L4.1, U6.6 (SW)
unnamed: C27.2, D9.1 (K), U6.1 (BOOST)
unnamed: C29.1, L2.2, L6.1
unnamed: C31.1, C32.1, R43.2, U8.3 (CS)
unnamed: C31.2, R36.1
unnamed: C36.1, L6.2, L7.1
unnamed: C37.2, R37.2, R38.1, U5.3 (FB)
unnamed: C38.2, R39.2, R40.1, U6.3 (FB)
unnamed: C41.1, L7.2, L9.1
unnamed: C49.1, C50.1, C51.1, D11.1 (K), L10.1
unnamed: C52.1, C54.2, L9.2, R47.1
unnamed: C52.2, Q15.1 (B), R52.2, R53.1
unnamed: C54.1, DA1.3 (+IN), RV1.2
unnamed: C59.1, Q17.1 (B), R60.2, R61.1
unnamed: C59.2, Q15.3 (C), R55.2
unnamed: C60.1, Q15.2 (E), R56.1
unnamed: C61.1, Q16.3 (D), R59.2, RV1.3
unnamed: C63.1, R66.2, R67.1, U10.1 (XI/ICLK)
unnamed: C63.2, Q17.3 (C), R62.2
unnamed: C64.1, Q17.2 (E), R63.1
unnamed: C67.1, C70.1, L12.1
unnamed: C67.2, L11.2, Q18.2 (D)
unnamed: C71.1, D12.1 (K), R77.2
unnamed: C75.1, Q23.1 (B), R84.2, R85.1
unnamed: C75.2, R78.1, U10.5 (CLK)
unnamed: C77.1, U11.5 (PD0), Y1.2
unnamed: C78.1, U11.6 (PD1), Y1.1
unnamed: C80.1, U11.3 (PC14), Y2.2
unnamed: C81.1, U11.4 (PC15), Y2.1
unnamed: C82.1, Q24.1 (G), RV2.2
unnamed: C82.2, L13.2, Q23.3 (C)
unnamed: C85.1, R91.2, U12.18 (~RESET)
unnamed: C90.1, C93.1, L15.1
unnamed: C90.2, L14.2, Q24.3 (D)
unnamed: C99.1, J9.2, L15.2
unnamed: C101.1, C103.1, K1.1 (COIL+)
unnamed: C102.1, C104.1, K2.1 (COIL+)
unnamed: C105.1, K1.4 (NO_1)
unnamed: C106.1, K2.4 (NO_1)
unnamed: C107.1, C109.1, K3.1 (COIL+)
unnamed: C108.1, C110.1, K4.1 (COIL+)
unnamed: C111.1, K3.4 (NO_1)
unnamed: C112.1, K4.4 (NO_1)
unnamed: C113.1, C115.1, K5.1 (COIL+)
unnamed: C114.1, C116.1, K6.1 (COIL+)
unnamed: C117.1, K5.4 (NO_1)
unnamed: C118.1, C119.2, K6.4 (NO_1)
unnamed: D4.2 (A), L1.2, U4.1 (SW)
unnamed: D7.1 (K), L5.1, U7.4 (LX)
unnamed: D10.1 (K), R41.2, U8.6 (OUT)
unnamed: D10.2 (A), Q12.1 (G), R41.1, R42.1
unnamed: D11.2 (A), L8.2, Q12.2 (D)
unnamed: D12.2 (A), R73.2, R74.1
unnamed: DA1.2 (-IN), R64.2, R65.1
unnamed: DA1.6 (OUT), Q18.1 (G), R64.1
unnamed: Q1.1 (B), R6.1
unnamed: Q1.3 (C), R18.2
unnamed: Q2.1 (B), R7.1
unnamed: Q2.3 (C), R19.2
unnamed: Q3.1 (B), R8.1
unnamed: Q3.3 (C), R20.2
unnamed: Q4.1 (B), R9.1
unnamed: Q4.3 (C), R21.2
unnamed: Q5.1 (B), R10.1
unnamed: Q5.3 (C), R22.2
unnamed: Q6.1 (G), R12.2, R18.1
unnamed: Q6.3 (D), R24.1
unnamed: Q7.1 (G), R13.2, R19.1
unnamed: Q8.1 (G), R14.2, R20.1
unnamed: Q9.1 (G), R15.2, R21.1
unnamed: Q10.1 (G), R16.2, R22.1
unnamed: Q11.2 (E), R29.1, R36.2
unnamed: Q12.3 (S), R43.1, R44.1, R45.1, R46.1, R48.1
unnamed: Q13.1 (B), R49.1
unnamed: Q13.3 (C), R51.2
unnamed: Q14.1 (G), R50.2, R51.1
unnamed: Q16.1 (G), R54.1
unnamed: Q19.1 (B), R70.1
unnamed: Q19.3 (C), R76.2
unnamed: Q20.1 (G), R72.2, R76.1
unnamed: Q21.1 (B), R81.1
unnamed: Q21.3 (C), R87.2
unnamed: Q22.1 (G), R82.2, R87.1
unnamed: R1.1, U1.2 (1A)
unnamed: R2.1, U1.3 (2A)
unnamed: R3.1, U2.2 (1A)
unnamed: R26.1, U3.8 (SDATA)
unnamed: R26.2, U1.6 (2B)
unnamed: R27.1, U3.9 (FSYNC)
unnamed: R27.2, U2.7 (1B)
unnamed: R28.1, U3.7 (SCLK)
unnamed: R28.2, U1.7 (1B)
unnamed: R33.2, U3.1 (FS_ADJUST)
unnamed: R58.2, U9.1 (W), U9.8 (A)
unnamed: R71.2, U10.7 (OE)
unnamed: R88.2, RV2.1
unnamed: U3.6 (MCLK), X1.5 (OUT)
POWERS_3.5: C12.1, C17.1, C28.1, C34.1, L1.1, L8.1, Q7.2 (D), U4.4 (EN), U4.5 (VIN)
PWR_3.5_5: C98.1, C100.1, Q8.3 (D), R91.1, U12.9 (VDD)
PWR_3.5_12: C24.1, C25.1, C30.1, C35.1, C40.1, C56.1, C58.1, D4.1 (K), DA1.7 (+VS), R35.1, R59.1, U8.7 (VCC)
PWR_3.5_OUT: C53.1, C55.1, C57.1, C65.1, C66.1, L10.2, L11.1, R57.1, R68.1
PWR_144_5: C68.1, C72.1, C73.1, Q10.3 (D), Q22.2 (S), R52.1, R55.1, R60.1, R62.1, R66.1, R71.1, R82.1, R84.1, U10.2 (VDD), U10.4 (S1), U10.6 (S0)
PWR_144_OUT: C89.1, C92.1, C96.1, L14.1, Q9.3 (D)
REG_3.3V: C33.1, C39.1, C44.1, C83.1, C84.1, C87.1, C91.1, C94.1, C97.1, L5.2, Q14.2 (S), R50.1, R75.1, U7.6 (OUT), U11.1 (VBAT), U11.9 (VDDA), U11.24 (VDD), U11.36 (VDD), U11.48 (VDD)
REG_5V: C4.1, C5.1, C7.1, C8.1, C18.1, C21.1, C37.1, C42.1, C45.1, C47.1, D8.2 (A), L3.2, Q8.2 (S), Q10.2 (S), Q20.2 (S), R14.1, R16.1, R37.1, R72.1, U1.8 (VCCB), U2.8 (VCCB), U3.4 (DVDD), U3.15 (AVDD), X1.8 (Vcc)
RESET: C69.1, J2.1, R75.2, U11.7 (NRST)
SWCLK: J10.2, U11.37 (PA14)
SWDIO: J10.3, U11.34 (PA13)
SW_3.3V: C2.1, C3.1, C62.1, C95.2, Q14.3 (D), R80.1, R83.1, R86.1, R89.1, R90.1, R92.1, R93.1, R94.1, R95.1, U1.1 (VCCA), U1.5 (DIR), U2.1 (VCCA), U2.5 (DIR), U9.2 (Vdd), U13.8 (VCC)

Notes on the sheet:
4.32V P-P @ 10 Ohm
144-146MHz 1.5V P-P 8.5mW @ 33 Ohm
7.4V 2 cells
Power sources activation logic
SDA
Button
Address = 20H
SSD1327 Display
Coilcraft 0807SQ-22NJLC
ADC_U3.5_OUT=0.125PWR_3.5_OUT
3V P-P 18MHz
Left
1 - Enable 0 - Disable
Coilcraft MSS1210-473MED
GND
Address = 58H
Right
To 3.5MHz antenna
+7.4V
200V P-P at antenna equivalent. Antenna equivalents: Short: 240 Ohm resistor in series with 35pF capacitor. Long: 100 Ohm resistor in series with 75pF capacitor.
VCC
Failure LED
Programming
0.00972*Uant
SCL
Wurth Elektronik 7447709151
HC-06 Bluetooth
ADC_UBATT=0.32UBATT
Address = A0H
Coilcraft 2222SQ-301GEC
Wurth Elektronik 7447798131
Peak to peak (in): 3.50MHz - 0.34V 3.65MHz - 0.3V 18.00MHz - 1.5V 18.25MHz - 1V
Peak to peak (out): 3.50MHz - 0.96V 3.65MHz - 0.96V 18.00MHz - 77mV 18.25MHz - 77mV
1 - Enable 3.5MHz powers 0 - Disable 3.5MHz powers
Switcheable 3.3V
To 144MHz 50 Ohm antenna
1 - Off 0 - On
1 - On 0 - Off

Board: 2 copper layers, 120.0 x 48.3 mm, 301 parts (138 on the bottom side), 165 nets.

## Commit log (part)

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2021-06-19 PCB seems to be ready
2021-06-19 Generated gerber files
2021-07-01 Updated Gerber files
2021-07-04 HAL is able to measure various voltages (in ADC values)
2021-07-04 Added new commands to get various fox voltages
2021-07-04 Able to report UAnt (ADC)
2021-07-04 Able to respond to "Get UBatt ADC" and "Get U80m ADC" commands
2021-07-04 Able to send "Get U80m ADC" command.
2021-07-04 Able to regulate U80m voltage
2021-07-04 Two new commands to get fox voltages
2021-07-05 Able to display U80m in volts
2021-07-05 Able to regulate U80m digitally (via digital feedback)
2021-07-05 Fast U80m lock
2021-07-06 Power calibrations
2021-07-07 Tone generation for 144MHz tract
2021-07-07 Refactored fox preparation for cycle
2021-07-08 - Fox is able to prepare itself to first transmission - Some refactoring
2021-07-10 - Fox case (in progress) - Initial antenna matching
2021-07-10 - Fixed bug with 3.5MHz high power setting - Described events
2021-07-13 Started to implement events processing on smartphone
2021-07-13 Able to process "Fox is armed" event
2021-07-13 Able to see antenna matching events
2021-07-13 Waiting for U80m stabilization before matching
2021-07-14 Fixed suicidal fox behaviour (enabled 144MHz tract and manipulator on reset)
2021-07-14 Correct fox disarming
2021-07-16 Able to rename bluetooth device after fox rename.
2021-07-16 Second antenna matching before transmission start
2021-07-25 Hardware controls events are processable in main loop
2021-07-31 Antenna matching graph
2021-08-03 Block fox disarming when it not armed or antenna matching in progress
2021-08-08 - Encoder stabilization - Initial menu implementation
2021-09-03 Scroll in menu
2021-09-11 Hardware buttons noise suppression
2021-09-11 Able to call menu leaf action method
2021-09-11 Started to implement real menu
2021-09-18 Able to switch profiles from fox
2021-09-18 More refactoring
2021-09-18 Get rid of insecure sprintf's
2021-09-19 Able to switch frequency range
2021-10-09 Huge refactoring, ordered .h files and includes
2021-10-09 No more implicit declarations
2021-10-10 Lots of warnings extreminated.
2021-10-10 Frequency setup from fox.
2021-10-16 Able to set fox speed from menu.
2021-10-23 Setting cycle type and ending tone duration.
2021-10-28 Able to set TX time
2021-10-30 Able to set fox start time
2021-10-30 Able to arm fox from meny
2021-10-30 Able to disarm fox, but memory seems to be damaged
2021-10-30 Menu nodes texts are in FLASH now
2021-10-31 Able to set TX power from fox menu
2021-10-31 Added settings lock for armed fox
2021-10-31 Fox is able to report last failure code via bluetooth
2021-10-31 Graceful shutdown with error logging in case of failure
2021-11-03 Fixed a bug in self-diagnostics
2021-11-04 Some refactoring
2021-11-05 Fixed a bug with display re-initialization
2021-11-07 Sleepmode current is 4mA
2021-11-07 Two sleepmodes, correct sleep during cycle.
2021-11-08 Sleep consumption is 3.56mA
2021-11-10 Fixed a bug with inability to connect to fox after sleepmode.
2021-11-10 Fixed a bug with inability to send "entering sleepmode" event
2021-11-11 Debugging define to disable antenna matching
2021-11-13 Updating bluetooth name after EEPROM format.
2021-11-13 Some tidying up
2021-11-13 Looks like firmware is done
2021-11-13 Fixed a bug in menu text
2021-11-13 Able to switch "Connect" button.
2021-11-13 Model + asynchronous handlers
2021-11-14 Refreshing foxes list by click
2021-11-14 Able to display bluetooth errors without crashes
2021-11-14 Correct connection and disconnection to/from fox.
2021-11-15 Fixed a bug with losing fonts due to transparency corruption.
2021-11-16 Added fox identification command to protocol description
2021-11-18 Fixed a bug with renaming bluetooth module during EEPROM format
2021-11-18 Able to identify is device a fox or not
2021-11-19 Fixed a bug with U80m control loop still enabled after a cycle
2021-11-20 Storing start and end times as timestapms
2021-11-20 Much better logic for setting start and end times
2021-11-20 Able to get fox name and set fox time
2021-11-21 Able to rename a fox without a problem
2021-11-21 Fixed a bug with disabled fox picker
2021-11-21 Fox name validation
2021-11-22 Interface for fox profile selection
2021-11-23 Profiles count + control over "Add profile" button
2021-11-23 Ability to add a profile to a fox
2021-11-24 More refactoring - removed unnecessary links to main model
2021-11-24 - Refactoring - Ability to rename profile
2021-11-24 Some UI tweaks
2021-11-26 More UI design
2021-11-28 Correct toggling between frequency ranges
2021-11-28 Styles in App.xaml
2021-11-30 Partially done callsign reading, found a bug with a double fox answer on get code
2021-12-01 - Correctly loading fox profile - Able to display callsign
2021-12-03 Able to set fox speed
2021-12-04 Able to set fox callsing
2021-12-04 Able to set TX duration
2021-12-05 Removed "Debug" directory from repo
2021-12-05 Controls are being disabled while fox commands are running.
2021-12-05 - Cycle settings - Dirty hack to avoid fox hanging (will be fixed later)
2021-12-05 Fast durations change buttons
2021-12-09 Ability to set and fine-tune start and finish times.
2021-12-12 Able to load fox power
2021-12-15 Now commands sending is synchronized, so no fox hangs must occur.
2021-12-15 - No need to disable buttons after click - Fixed some XAML logic bugs - Dirty hack with after command wait time
2021-12-16 Found a bug in firmware, when "Arm Fox OK" response is being sent when fox armed manually.
2021-12-17 Phone app isn't crashing now after the manual fox arming.
2021-12-19 Emitting "Fox arming initiated" event
2021-12-19 Emitting "Fox disarmed" event
2021-12-19 Able to process "Fox disarmed" event
2021-12-19 Some changes for easier debugging
2021-12-20 Fixed a bug with incorrect commands execution when interrupd came during EEPROM write
2021-12-20 100% of charge is 8.4V now
2021-12-22 Correctly working basic arming window
2021-12-22 Matching event now contains information about total matching steps + antenna voltage now in volts.
2021-12-22 Fixed wrong antenna matching event packet size
2021-12-22 Displaying antenna matching stage
2021-12-23 Working antenna matching graph
2021-12-23 Some mallocs eliminated
2021-12-24 Some mallocs are eliminated
2021-12-24 Mallocless fox - all executable code is not using memory management at all
2021-12-25 Re-enabled antenna matching
2021-12-25 Added boot logo
2021-12-25 STM32 HAL bumped to 1.8.0
2021-12-25 Fixed buffer lengths for meny items
2021-12-25 Buttons enable/disable logic
2021-12-25 More logic for buttons
2021-12-26 Now profile names can contain "."
2021-12-26 Added information on antenna equivalents
2021-12-26 Sending "Profile switched" event
2021-12-27 Fast UART interrupt handler
2021-12-27 Antenna matching from main cycle, without dumb delays.
2021-12-27 Updated L12 value for matching with antennas of different lengths
2021-12-28 Some antenna matching data in FoxState.AntennaMatching
2021-12-28 Fox is able to respond to "Get antenna matching data" command
2021-12-28 Able to get antenna matching status from fox.
2021-12-28 Fixed forgotten response
2021-12-28 Updated matching protocol
2021-12-28 Added current antenna voltage to matching status
2021-12-28 Partially reworked matching screen
2021-12-28 Partially reworked arming display
2021-12-28 Minor fixes
2021-12-29 Small refactoring
2021-12-29 Moved some code to antenna matching manager
2021-12-30 Fox disarmed event eliminated from phone.
2021-12-30 Eliminated "On Profile Switched" event
2021-12-30 Eradicated some events from the fox side
2021-12-31 Able to read "Is new profile changes" data, but fox needs a fix.
2021-12-31 Events elimination completed.
2022-01-04 Able to handle fox-sided disconnection
2022-01-04 Correctly processing manual disconnect
2022-01-04 Fixed a bug with inability to display matching data if fox was disarmed before connection
2022-01-05 Updated Full schematic.pdf
2022-01-06 Initial service menu
2022-01-07 Fixed display output for new version of compiler
2022-01-09 Priority events are now in separate thread to make events processing faster
2022-01-09 Minor bugs fixed
2022-01-12 Able to get last error code.
2022-01-13 Able to reset last error code, but need a minor fix on a fox side.
2022-01-13 Fox is able to update her serial number
2022-01-15 Able to update fox serial number, however, update didn't shown on main screen
2022-01-16 Able to display battery level averaaged ADC value
2022-01-17 Commands to get and set Ubatt(ADC) -> Ubatt(Volts) factors.
2022-01-17 Able to read UBatt(ADC) -> UBatt(volts) factors.
2022-01-18 Setting Ubatt factors, but somehow fox doesn't accept it.
2022-01-20 Fox is able now to accept Ubatt(Volts) to Battery level factors
2022-01-20 Able to get Ubatt(Volts) to battery level factors
2022-01-22 Fox must be able now to get/set U80m(ADC)->U80m(Volts) factors.
2022-01-24 Able to read U80m voltage
2022-01-26 Able to reset U80m factors
2022-01-26 Able to set U80m factors
2022-01-28 Able to get/set/reset P80m -> U80m settings
2022-01-28 Fox must be able to get/set Uant(ADC)->Uant(Volts) factors.
2022-01-29 Able to get Uant ADC and voltage values
2022-01-29 Fixed a bug with incorrectly setting Uant factors.
2022-01-30 Able to initiate Force TX, but then emergency halt
2022-01-30 Able to force TX on
2022-01-31 Able to send "Return to normal TX" command, but it doesn't work on the fox side.
2022-01-31 Force TX ON is ready.
2022-02-01 - Fixed bugs with renaming bluetooth device and data packing
2022-02-01 - Fixed a bug with incorrect pointers to data in "Get AB factors" commands
    - Implemented "Read RTC calibration data" command
2022-02-01 Able to get RTC calibration value
2022-02-01 Fixed an incorrect validation response.
2022-02-01 Successfull -> Successful
2022-02-05 Decreased EEPROM's I2C speed, decreased interwrite interval
2022-02-06 Fox must be able to get/set disarm on discharge value.
2022-02-06 Able to set disarm-on-discharge value
2022-02-07 Fast EEPROM page write
2022-02-08 2m antenna (3d printable!)
2022-02-08 Squashed a bug with wrong buttons text on manual arming.
2022-02-09 Some refactoring in commands validation.
2022-02-09 Bootloader flag in constant header
2022-02-09 Project for bootloader
2022-02-10 Able to start main fox code from bootloader
2022-02-11 Able to initialize display in bootloader
2022-02-11 Logger in bootloader
2022-02-13 UART and packet processor in bootloader
2022-02-13 VTOR relocation at bootloader stage
2022-02-13 Bootloader is able to jump to OEP on both buttons press
2022-02-13 Fox hangs on exit from bootloader (by buttons) and I have no idea why
2022-02-13 Message on DFU mode enter
2022-02-14 No hang on UART interrupt
2022-02-14 Refactoring
2022-02-14 Fixed null pointer dereferencing in FMGL
2022-02-15 Able to reconnect to fox in bootloader mode.
2022-02-15 Fixed response size
2022-02-18 Refactored connection to fox in bootloader mode
2022-02-18 Ready to implement "Return from bootloader" command.
2022-02-18 Fox is able to reboot from bootloader to main code via command
2022-02-19 Able to get flash addresses
2022-02-19 Fixed a bug with a start address
2022-02-19 Able to read FLASH (in dirty, debug style)
2022-02-19 Able to save firmware after dumping.
2022-02-19 Correct script to prepare firmware
2022-02-23 Partially working permissions requests, also now app works on Android 7
2022-02-23 Working fox file dumping,
2022-02-25 Fixed a bug with invisible progress dialog during FLASH backup
2022-02-26 Fox must be able to erase FLASH pages
2022-02-26 Firmware dump on main thread
2022-08-07 Split current schematic version into two
2022-08-07 Changed 3.3V regulator to more efficient
2022-08-07 Removed 30 capacitors from antenna tuner by swithcing to high-voltage capacitors
2022-08-08 Prepared to start PCB tracing
2022-08-08 - New antenna matcher
    - Ready to trace PCB
2022-08-09 Partially traced new PCB
2022-08-10 - PCB tracing in progress
2022-08-13 PCB tracing in progress
2022-08-14 PCB tracing is close to an end
